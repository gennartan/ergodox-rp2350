## tests/config/testcase.yaml
```yaml
tests:
  ergodox.config:
    platform_allow:
      - native_sim/native/64
    tags:
      - keyboard
      - nvs
```
